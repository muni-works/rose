# Repository muni-works/rose (continued)

## KiCad design brain/brain.kicad_pcb

Schematic: brain.kicad_sch

Parts:
C1, C2, C8, C9, C21, C22: 10u 25V; C_0603_1608Metric
C3, C4: 470u 25V; CP_Elec_8x10.5
C5: 10n; C_0402_1005Metric
C6, C10, C14, C19, C23, C27, C85, C86, C115, C272, C278, C279, C284, C285, C286, C287, C288, C289, C292, C293, C294, C295, C296, C297, C299, C300, C305, C306, C307, C308, C309, C310, C313, C314, C315, C316, C317, C318, C322, C324, C327, C328, C329, C330, C331, C332, C333, C334, C337, C340, C343, C344, C345, C346, C347, C348, C349, C352, C353, C354, C357, C358, C359, C362, C363, C364: 100n; C_0402_1005Metric
C7, C15, C16, C17, C20, C32, C37, C42, C47, C68, C69, C70, C71, C72, C78, C79, C80, C81, C82, C89, C97, C105, C116, C117, C124, C125, C126, C127, C134, C135, C136, C137, C144, C145, C146, C147, C153, C154, C155, C156, C157, C158, C165, C166, C167, C168, C174, C175, C176, C177, C178, C179, C188, C189, C190, C197, C198, C213, C214, C215, C216, C217, C218, C222, C224, C225, C226, C237, C238, C239, C240, C249, C250, C264, C275, C276, C277, C282, C283, C290, C291, C298, C303, C304, C311, C312, C320, C325, C326, C336: 1u; C_0402_1005Metric
C11, C12, C13, C24, C25, C26, C28, C31, C33, C34, C35, C36, C38, C39, C40, C41, C43, C44, C45, C46, C49, C50, C52, C53, C55, C56, C58, C59, C61, C62, C64, C65, C87, C88, C90, C91, C92, C93, C94, C95, C96, C98, C99, C100, C101, C102, C103, C104, C108, C109, C110, C114, C118, C119, C120, C121, C122, C123: 22u; C_0603_1608Metric
C18, C48, C51, C54, C57, C60, C63, C112, C195, C196, C203, C204, C280, C281, C301, C302: 10u; C_0603_1608Metric
C29, C30, C106, C107: 47u; C_0805_2012Metric
C66, C67, C113: 100p; C_0402_1005Metric
C73, C74, C75, C76, C77, C321, C323, C338, C339: 2.2u; C_0402_1005Metric
C83, C335: 4.7u; C_0603_1608Metric
C84, C319: 1n 25V; C_0402_1005Metric
C111: 100n 25V; C_0402_1005Metric
C128, C129, C130, C131, C132, C133, C138, C139, C140, C141, C142, C143, C148, C149, C150, C151, C152, C159, C160, C161, C162, C163, C164, C169, C170, C171, C172, C173, C180, C181, C182, C183, C184, C185, C186, C187, C191, C192, C193, C194, C199, C200, C201, C202, C205, C206, C207, C208, C209, C210, C211, C212, C219, C220, C221, C223, C227, C228, C229, C230, C231, C232, C233, C234, C235, C236, C241, C242, C243, C244, C245, C246, C247, C248, C251, C252, C253, C254, C255, C256, C257, C258, C259, C260, C261, C262, C263, C265, C266, C267, C268, C269: 100n; C_0201_0603Metric
C270, C271: 18p; C_0402_1005Metric
C273, C274: 1n; C_0402_1005Metric
C341, C342: 10p; C_0402_1005Metric
C350, C351, C355, C356, C360, C361: 12p; C_0402_1005Metric
C365, C366, C367, C368, C369, C370: 4.7n; C_0402_1005Metric
D1: SMBJ15A; D_SMB
D2: SS34; D_SMA
D3: B5819W; D_SOD-123
D4: status R; LED_0603_1608Metric
D5: status G; LED_0603_1608Metric
D6: status B; LED_0603_1608Metric
D7, D8, D9, D10, D11, D12: PESD2CAN; SOT-23
F1: 6A hold 16V (1812); Fuse_1812_4532Metric
FB1, FB2, FB3, FB4, FB5, FB6: 120R@100MHz; L_0603_1608Metric
FB7: 600R@100MHz; L_0603_1608Metric
H1, H2, H3, H4: M3; MountingHole_3.2mm_M3_Pad_Via
J1: XT30PB(2+2)-M 12V + BMS CAN from spine; AMASS_XT30PB_2+2_M
J2: GH e-stop + pack status from spine; JST_GH_SM03B-GHS-TB_1x03-1MP_P1.25mm_Horizontal
J3: USB-C (device); USB_C_Receptacle_GCT_USB4105-xx-A_16P_TopMnt_Horizontal
J5: camera 0 (22-pin 0.5 mm, Pi CSI-2 4-lane); Hirose_FH12-22S-0.5SH_1x22-1MP_P0.50mm_Horizontal
J6: camera 1 (22-pin 0.5 mm, Pi CSI-2 4-lane); Hirose_FH12-22S-0.5SH_1x22-1MP_P0.50mm_Horizontal
J7: SoC console (UART2, 1.5 Mbaud); JST_GH_SM03B-GHS-TB_1x03-1MP_P1.25mm_Horizontal
J8: TC2030 SWD; Tag-Connect_TC2030-IDC-NL_2x03_P1.27mm_Vertical
J10: GH limb port: left arm (bus 0); JST_GH_SM05B-GHS-TB_1x05-1MP_P1.25mm_Horizontal
J11: GH limb port: right arm (bus 1); JST_GH_SM05B-GHS-TB_1x05-1MP_P1.25mm_Horizontal
J12: GH limb port: left leg (bus 2); JST_GH_SM05B-GHS-TB_1x05-1MP_P1.25mm_Horizontal
J13: GH limb port: right leg (bus 3); JST_GH_SM05B-GHS-TB_1x05-1MP_P1.25mm_Horizontal
J14: GH limb port: head (bus 4); JST_GH_SM05B-GHS-TB_1x05-1MP_P1.25mm_Horizontal
L1: 6.8u; L_Bourns_SRN6045TA
L2: 3.3u; L_Bourns_SRN6045TA
L3, L4, L5, L6: 0.22u; L_Taiyo-Yuden_MD-3030
L7, L8, L9, L10, L11, L12: 0.47u; L_1008_2520Metric
L13, L14, L15: 0.24u; L_Taiyo-Yuden_MD-3030
L16: 2.2u; L_1008_2520Metric
PF1, PF2, PF3, PF4, PF5, PF6, PF7, PF8, PF9, PF10, PF11, PF12, PF13, PF14, PF15, PF16, PF17, PF18, PF19, PF20, PF21, PF22, PF23, PF24, PF25, PF26, PF27, PF28, PF29, PF30, PF31, PF32: PWR_FLAG
R1, R2, R24, R25, R38, R41, R50, R71, R80, R89, R90, R91, R92, R93, R94, R95, R97, R98, R100, R101, R103: 10k; R_0402_1005Metric
R3, R5, R7, R9, R15, R17, R21, R32, R39, R42, R49, R74, R75: 100k; R_0402_1005Metric
R4: 22k; R_0402_1005Metric
R6, R8: 24.9k; R_0402_1005Metric
R10, R11, R12, R13, R18, R29, R30, R31: 100R; R_0402_1005Metric
R14, R33, R40: 120k; R_0402_1005Metric
R16: 20k; R_0402_1005Metric
R19, R20: 200k; R_0402_1005Metric
R22, R23, R26, R27, R28, R46, R70, R96, R99, R102: 0; R_0402_1005Metric
R34, R35, R36, R37, R76, R77, R78, R79: 2.2k; R_0402_1005Metric
R43: 4.7k; R_0402_1005Metric
R44, R47, R48, R116, R117, R118, R119, R120: 22R; R_0402_1005Metric
R45: 510k; R_0402_1005Metric
R51, R52: 8.2k 1%; R_0402_1005Metric
R53, R54, R55: 200R 1%; R_0402_1005Metric
R56, R57, R61, R62: 49.9R 1%; R_0201_0603Metric
R58, R63, R66, R67, R68, R69: 240R 1%; R_0201_0603Metric
R59, R60, R64, R65: 10k; R_0201_0603Metric
R72, R73: 5.1k; R_0402_1005Metric
R81, R82, R83, R84, R85, R86, R87, R88: 1k; R_0402_1005Metric
R104, R105, R106, R107, R108, R109, R110, R111, R112, R113, R114, R115: 60.4; R_0402_1005Metric
SW1: power key; SW_SPST_TL3342
SW2: maskrom/recovery; SW_SPST_TL3342
U1: LMR33610ADDAR; Texas_HSOP-8-1EP_3.9x4.9mm_P1.27mm_ThermalVias
U2: AP2112K-3.3; SOT-23-5
U3: LMR33640ADDA; Texas_HSOP-8-1EP_3.9x4.9mm_P1.27mm_ThermalVias
U4, U6: RK860-2; Rockchip_WLCSP-20_1.65x2.05mm_P0.4mm
U5: RK860-3; Rockchip_WLCSP-20_1.65x2.05mm_P0.4mm
U7: SY8089AAC; SOT-23-5
U8: SGM2576; SOT-23-5
U9: USBLC6-2SC6; SOT-23-6
U10: W25Q128JVS; SOIC-8_5.3x5.3mm_P1.27mm
U11, U12, U13: MCP2562FD-E/SN; SOIC-8_3.9x4.9mm_P1.27mm
U14, U15, U16: MCP251863T-E/9PX; VQFN-28-1EP_5x5mm_P0.5mm_EP3.25x3.25mm
U_DRAM0, U_DRAM1: W66DP2RQQAGJ (8Gb x32 LPDDR4X); BGA-200_10x14.5mm_Layout12x22_P0.8x0.65mm
U_EMMC: ZDEMMC32GA (32 GB eMMC 5.1); LFBGA-153_11.5x13mm_Layout14x14_P0.5mm
U_PMIC: RK806-1; ArtInChip_QFN-68-1EP_7x7mm_P0.35mm_EP5.49x5.49mm_ThermalVias
U_RT: STM32H723VGT6; LQFP-100_14x14mm_P0.5mm
U_SOC: RK3588S2; Rockchip_FCCSP-1253_17x17mm_P0.4mm
Y1: 24MHz; Crystal_SMD_2016-4Pin_2.0x1.6mm
Y2: 25MHz; Crystal_SMD_3225-4Pin_3.2x2.5mm
Y3, Y4, Y5: 40MHz; Crystal_SMD_3225-4Pin_3.2x2.5mm

Connections:
3V3_RT: C16.1, C17.1, C18.1, C327.1, C328.1, C329.1, C330.1, C331.1, C332.1, C333.1, C334.1, C335.1, C343.1, C345.1, C347.1, C349.1, C352.1, C353.1, C357.1, C358.1, C362.1, C363.1, FB7.1, J8.1 (VCC), R89.1, R90.1, R91.1, R97.1, R100.1, R103.1, U2.5 (VOUT), U10.8 (VCC), U11.5 (Vio), U12.5 (Vio), U13.5 (Vio), U14.14 (VIO), U14.26 (VDD), U15.14 (VIO), U15.26 (VDD), U16.14 (VIO), U16.26 (VDD), U_RT.6 (VBAT), U_RT.11 (VDD), U_RT.20 (VREF+), U_RT.27 (VDD), U_RT.50 (VDD), U_RT.75 (VDD), U_RT.100 (VDD)
5V_RT: C11.1, C12.1, C13.1, C14.1, C15.1, C344.1, C346.1, C348.1, C354.1, C359.1, C364.1, L1.2, PF3.1, R5.1, U2.1 (VIN), U2.3 (EN), U11.3 (VDD), U12.3 (VDD), U13.3 (VDD), U14.13 (VCC), U15.13 (VCC), U16.13 (VCC)
12V: C1.1, C2.1, C21.1, C22.1, C23.1, D1.2 (A2), D2.2 (A), F1.2, PF1.1, R3.1, R9.1, U3.2 (VIN)
12V_IN: F1.1, J1.1
12V_RT: C3.1, C4.1, C8.1, C9.1, C10.1, D2.1 (K), PF5.1, U1.2 (VIN), U1.3 (EN)
AVDD1V8_DDR_PLL_S0: C217.1, C218.1, PF23.1, R28.2, U_SOC.L15 (DDR_CH1_PLL_AVDD1V8), U_SOC.Y14 (DDR_CH0_PLL_AVDD1V8)
BB_CS_n: R91.2, U10.1 (~CS), U_RT.3 (PE4)
BB_HOLD_n: R90.2, U10.7 (~HOLD/~RESET/IO_{3})
BB_MISO: U10.2 (DO/IO_{1}), U_RT.4 (PE5)
BB_MOSI: U10.5 (DI/IO_{0}), U_RT.5 (PE6)
BB_SCK: U10.6 (CLK), U_RT.1 (PE2)
BB_WP_n: R89.2, U10.3 (~WP/IO_{2})
BIG0_LX: L13.1, U4.D3 (LX), U4.D4 (LX), U4.E3 (LX), U4.E4 (LX)
BIG1_LX: L14.1, U5.D3 (LX), U5.D4 (LX), U5.E3 (LX), U5.E4 (LX)
BIG_NPU_EN: R32.2, R33.1, U4.A2 (EN), U5.A2 (EN), U6.A2 (EN)
CAM0_CN: J5.8, U_SOC.AN41 (MIPI_CSI0_CLK0N)
CAM0_CP: J5.9, U_SOC.AN42 (MIPI_CSI0_CLK0P)
CAM0_D0N: J5.2, U_SOC.AL41 (MIPI_CSI0_D0N)
CAM0_D0P: J5.3, U_SOC.AL42 (MIPI_CSI0_D0P)
CAM0_D1N: J5.5, U_SOC.AK42 (MIPI_CSI0_D1N)
CAM0_D1P: J5.6, U_SOC.AK41 (MIPI_CSI0_D1P)
CAM0_D2N: J5.11, U_SOC.AT42 (MIPI_CSI0_D2N)
CAM0_D2P: J5.12, U_SOC.AT41 (MIPI_CSI0_D2P)
CAM0_D3N: J5.14, U_SOC.AP41 (MIPI_CSI0_D3N)
CAM0_D3P: J5.15, U_SOC.AP42 (MIPI_CSI0_D3P)
CAM0_PWDN: J5.17, U_SOC.D40 (UART7_TX_M2/SPI0_CS1_M2/GPIO1_B5_u)
CAM0_SCL: J5.20, R76.2, U_SOC.L39 (I2C4_SCL_M3/UART6_CTSN_M1/PWM1_M2/SPI4_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)
CAM0_SDA: J5.21, R77.2, U_SOC.D38 (VOP_POST_EMPTY/I2C4_SDA_M3/UART6_RTSN_M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)
CAM0_TRIG: J5.18, R87.2
CAM0_TRIG_RT: R87.1, U_RT.41 (PE11)
CAM1_CN: J6.8, U_SOC.BA41 (MIPI_DPHY0_RX_CLKN/MIPI_CPHY0_RX_TRIO1_B)
CAM1_CP: J6.9, U_SOC.BB41 (MIPI_DPHY0_RX_CLKP/MIPI_CPHY0_RX_TRIO1_C)
CAM1_D0N: J6.2, U_SOC.BB38 (MIPI_DPHY0_RX_D0N/MIPI_CPHY0_RX_TRIO0_A)
CAM1_D0P: J6.3, U_SOC.BA38 (MIPI_DPHY0_RX_D0P/MIPI_CPHY0_RX_TRIO0_B)
CAM1_D1N: J6.5, U_SOC.AY40 (MIPI_DPHY0_RX_D1N/MIPI_CPHY0_RX_TRIO0_C)
CAM1_D1P: J6.6, U_SOC.BA40 (MIPI_DPHY0_RX_D1P/MIPI_CPHY0_RX_TRIO1_A)
CAM1_D2N: J6.11, U_SOC.BA42 (MIPI_DPHY0_RX_D2N/MIPI_CPHY0_RX_TRIO2_A)
CAM1_D2P: J6.12, U_SOC.AY42 (MIPI_DPHY0_RX_D2P/MIPI_CPHY0_RX_TRIO2_B)
CAM1_D3N: J6.14, U_SOC.AW42 (MIPI_DPHY0_RX_D3N/MIPI_CPHY0_RX_TRIO2_C)
CAM1_D3P: J6.15, U_SOC.AW41 (MIPI_DPHY0_RX_D3P/NO_USE)
CAM1_PWDN: J6.17, U_SOC.D39 (SPI2_CLK_M0/GPIO1_A6_d)
CAM1_SCL: J6.20, R78.2, U_SOC.L37 (MIPI_CAMERA3_CLK_M0/I2C8_SCL_M2/UART1_R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)
CAM1_SDA: J6.21, R79.2, U_SOC.G38 (MIPI_CAMERA4_CLK_M0/I2C8_SDA_M2/UART1_C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)
CAM1_TRIG: J6.18, R88.2
CAM1_TRIG_RT: R88.1, U_RT.43 (PE13)
CAN0_H: D7.1 (A1), J10.1, R104.1, U11.7 (CANH)
CAN0_L: D7.2 (A2), J10.2, R105.2, U11.6 (CANL)
CAN0_RX: U11.4 (RXD), U_RT.81 (PD0)
CAN0_STBY: R92.1, U11.8 (STBY), U_RT.55 (PD8)
CAN0_TSPLIT: C365.1, R104.2, R105.1
CAN0_TX: U11.1 (TXD), U_RT.82 (PD1)
CAN1_H: D8.1 (A1), J11.1, R106.1, U12.7 (CANH)
CAN1_L: D8.2 (A2), J11.2, R107.2, U12.6 (CANL)
CAN1_RX: U12.4 (RXD), U_RT.91 (PB5)
CAN1_STBY: R93.1, U12.8 (STBY), U_RT.56 (PD9)
CAN1_TSPLIT: C366.1, R106.2, R107.1
CAN1_TX: U12.1 (TXD), U_RT.92 (PB6)
CAN2_H: D9.1 (A1), J12.1, R108.1, U13.7 (CANH)
CAN2_L: D9.2 (A2), J12.2, R109.2, U13.6 (CANL)
CAN2_RX: U13.4 (RXD), U_RT.59 (PD12)
CAN2_STBY: R94.1, U13.8 (STBY), U_RT.57 (PD10)
CAN2_TSPLIT: C367.1, R108.2, R109.1
CAN2_TX: U13.1 (TXD), U_RT.60 (PD13)
CAN3_H: D10.1 (A1), J13.1, R110.1, U14.17 (CANH)
CAN3_L: D10.2 (A2), J13.2, R111.2, U14.16 (CANL)
CAN3_RXI: U14.1 (RXCAN), U14.11 (RXD)
CAN3_STBY: R95.1, U14.18 (STBY)
CAN3_TSPLIT: C368.1, R110.2, R111.1
CAN3_TXD: R96.2, U14.28 (TXCAN)
CAN3_TXI: R96.1, U14.20 (TXD)
CAN4_H: D11.1 (A1), J14.1, R112.1, U15.17 (CANH)
CAN4_L: D11.2 (A2), J14.2, R113.2, U15.16 (CANL)
CAN4_RXI: U15.1 (RXCAN), U15.11 (RXD)
CAN4_STBY: R98.1, U15.18 (STBY)
CAN4_TSPLIT: C369.1, R112.2, R113.1
CAN4_TXD: R99.2, U15.28 (TXCAN)
CAN4_TXI: R99.1, U15.20 (TXD)
CAN5_H: D12.1 (A1), J1.3, R114.1, U16.17 (CANH)
CAN5_L: D12.2 (A2), J1.4, R115.2, U16.16 (CANL)
CAN5_RXI: U16.1 (RXCAN), U16.11 (RXD)
CAN5_STBY: R101.1, U16.18 (STBY), U_RT.58 (PD11)
CAN5_TSPLIT: C370.1, R114.2, R115.1
CAN5_TXD: R102.2, U16.28 (TXCAN)
CAN5_TXI: R102.1, U16.20 (TXD)
CANX0_CS: R97.2, U14.25 (~CS), U_RT.84 (PD3)
CANX0_INT: U14.3 (~INT), U_RT.85 (PD4)
CANX0_OSC1: C350.1, U14.5 (OSC1), Y3.1
CANX0_OSC2: C351.1, U14.4 (OSC2), Y3.3
CANX1_CS: R100.2, U15.25 (~CS), U_RT.86 (PD5)
CANX1_INT: U15.3 (~INT), U_RT.87 (PD6)
CANX1_OSC1: C355.1, U15.5 (OSC1), Y4.1
CANX1_OSC2: C356.1, U15.4 (OSC2), Y4.3
CANX2_CS: R103.2, U16.25 (~CS), U_RT.78 (PC10)
CANX2_INT: U16.3 (~INT), U_RT.79 (PC11)
CANX2_OSC1: C360.1, U16.5 (OSC1), Y5.1
CANX2_OSC2: C361.1, U16.4 (OSC2), Y5.3
CANX_MISO: U14.24 (SDO), U15.24 (SDO), U16.24 (SDO), U_RT.30 (PA6)
CANX_MOSI: U14.23 (SDI), U15.23 (SDI), U16.23 (SDI), U_RT.88 (PD7)
CANX_SCK: U14.22 (SCK), U15.22 (SCK), U16.22 (SCK), U_RT.29 (PA5)
D0A_CA0: U_DRAM0.H2 (CA0_A), U_SOC.U1 (DDR_CH0_A0_A)
D0A_CA1: U_DRAM0.J2 (CA1_A), U_SOC.AC2 (DDR_CH0_A1_A)
D0A_CA2: U_DRAM0.H9 (CA2_A), U_SOC.AF1 (DDR_CH0_A2_A)
D0A_CA3: U_DRAM0.H10 (CA3_A), U_SOC.AL2 (DDR_CH0_A3_A)
D0A_CA4: U_DRAM0.H11 (CA4_A), U_SOC.Y1 (DDR_CH0_A4_A)
D0A_CA5: U_DRAM0.J11 (CA5_A), U_SOC.AG2 (DDR_CH0_A5_A)
D0A_CKE0: R56.2, U_DRAM0.J4 (CKE0_A)
D0A_CKE0_SOC: R56.1, U_SOC.AK1 (DDR_CH0_LP4/4X_CKE0/LP5_CS0_A)
D0A_CK_c: U_DRAM0.J9 (CK_c_A), U_SOC.AA1 (DDR_CH0_CKB_A)
D0A_CK_t: U_DRAM0.J8 (CK_t_A), U_SOC.AA2 (DDR_CH0_CK_A)
D0A_CS0: U_DRAM0.H4 (CS0_A), U_SOC.Y2 (DDR_CH0_LP4/4X_CS0_A)
D0A_DMI0: U_DRAM0.C3 (DMI0_A), U_SOC.AE1 (DDR_CH0_DM0_A)
D0A_DMI1: U_DRAM0.C10 (DMI1_A), U_SOC.AK4 (DDR_CH0_DM1_A)
D0A_DQ0: U_DRAM0.B2 (DQ0_A), U_SOC.AJ2 (DDR_CH0_DQ0_A)
D0A_DQ1: U_DRAM0.C2 (DQ1_A), U_SOC.AB4 (DDR_CH0_DQ1_A)
D0A_DQ2: U_DRAM0.E2 (DQ2_A), U_SOC.AJ1 (DDR_CH0_DQ2_A)
D0A_DQ3: U_DRAM0.F2 (DQ3_A), U_SOC.AB3 (DDR_CH0_DQ3_A)
D0A_DQ4: U_DRAM0.F4 (DQ4_A), U_SOC.AB5 (DDR_CH0_DQ4_A)
D0A_DQ5: U_DRAM0.E4 (DQ5_A), U_SOC.AE5 (DDR_CH0_DQ5_A)
D0A_DQ6: U_DRAM0.C4 (DQ6_A), U_SOC.AE2 (DDR_CH0_DQ6_A)
D0A_DQ7: U_DRAM0.B4 (DQ7_A), U_SOC.AF3 (DDR_CH0_DQ7_A)
D0A_DQ8: U_DRAM0.B11 (DQ8_A), U_SOC.AK5 (DDR_CH0_DQ8_A)
D0A_DQ9: U_DRAM0.C11 (DQ9_A), U_SOC.AN5 (DDR_CH0_DQ9_A)
D0A_DQ10: U_DRAM0.E11 (DQ10_A), U_SOC.AN4 (DDR_CH0_DQ10_A)
D0A_DQ11: U_DRAM0.F11 (DQ11_A), U_SOC.AJ6 (DDR_CH0_DQ11_A)
D0A_DQ12: U_DRAM0.F9 (DQ12_A), U_SOC.AJ3 (DDR_CH0_DQ12_A)
D0A_DQ13: U_DRAM0.E9 (DQ13_A), U_SOC.AK3 (DDR_CH0_DQ13_A)
D0A_DQ14: U_DRAM0.C9 (DQ14_A), U_SOC.AF4 (DDR_CH0_DQ14_A)
D0A_DQ15: U_DRAM0.B9 (DQ15_A), U_SOC.AF5 (DDR_CH0_DQ15_A)
D0A_DQS0_c: U_DRAM0.E3 (DQS0_c_A), U_SOC.AN2 (DDR_CH0_DQS0N_A)
D0A_DQS0_t: U_DRAM0.D3 (DQS0_t_A), U_SOC.AN1 (DDR_CH0_DQS0P_A)
D0A_DQS1_c: U_DRAM0.E10 (DQS1_c_A), U_SOC.AV3 (DDR_CH0_DQS1N_A)
D0A_DQS1_t: U_DRAM0.D10 (DQS1_t_A), U_SOC.AV4 (DDR_CH0_DQS1P_A)
D0B_CA0: U_DRAM0.R2 (CA0_B), U_SOC.U2 (DDR_CH0_A0_B)
D0B_CA1: U_DRAM0.P2 (CA1_B), U_SOC.R2 (DDR_CH0_A1_B)
D0B_CA2: U_DRAM0.R9 (CA2_B), U_SOC.R1 (DDR_CH0_A2_B)
D0B_CA3: U_DRAM0.R10 (CA3_B), U_SOC.D2 (DDR_CH0_A3_B)
D0B_CA4: U_DRAM0.R11 (CA4_B), U_SOC.E1 (DDR_CH0_A4_B)
D0B_CA5: U_DRAM0.P11 (CA5_B), U_SOC.L1 (DDR_CH0_A5_B)
D0B_CKE0: R57.2, U_DRAM0.P4 (CKE0_B)
D0B_CKE0_SOC: R57.1, U_SOC.H2 (DDR_CH0_LP4/4X_CKE0/LP5_CS0_B)
D0B_CK_c: U_DRAM0.P9 (CK_c_B), U_SOC.V1 (DDR_CH0_CKB_B)
D0B_CK_t: U_DRAM0.P8 (CK_t_B), U_SOC.V2 (DDR_CH0_CK_B)
D0B_CS0: U_DRAM0.R4 (CS0_B), U_SOC.J1 (DDR_CH0_LP4/4X_CS0_B)
D0B_DMI0: U_DRAM0.Y3 (DMI0_B), U_SOC.V5 (DDR_CH0_DM0_B)
D0B_DMI1: U_DRAM0.Y10 (DMI1_B), U_SOC.G2 (DDR_CH0_DM1_B)
D0B_DQ0: U_DRAM0.AA2 (DQ0_B), U_SOC.U3 (DDR_CH0_DQ0_B)
D0B_DQ1: U_DRAM0.Y2 (DQ1_B), U_SOC.AA5 (DDR_CH0_DQ1_B)
D0B_DQ2: U_DRAM0.V2 (DQ2_B), U_SOC.N1 (DDR_CH0_DQ2_B)
D0B_DQ3: U_DRAM0.U2 (DQ3_B), U_SOC.U5 (DDR_CH0_DQ3_B)
D0B_DQ4: U_DRAM0.U4 (DQ4_B), U_SOC.P4 (DDR_CH0_DQ4_B)
D0B_DQ5: U_DRAM0.V4 (DQ5_B), U_SOC.P3 (DDR_CH0_DQ5_B)
D0B_DQ6: U_DRAM0.Y4 (DQ6_B), U_SOC.U4 (DDR_CH0_DQ6_B)
D0B_DQ7: U_DRAM0.AA4 (DQ7_B), U_SOC.P5 (DDR_CH0_DQ7_B)
D0B_DQ8: U_DRAM0.AA11 (DQ8_B), U_SOC.G5 (DDR_CH0_DQ8_B)
D0B_DQ9: U_DRAM0.Y11 (DQ9_B), U_SOC.J3 (DDR_CH0_DQ9_B)
D0B_DQ10: U_DRAM0.V11 (DQ10_B), U_SOC.G4 (DDR_CH0_DQ10_B)
D0B_DQ11: U_DRAM0.U11 (DQ11_B), U_SOC.J4 (DDR_CH0_DQ11_B)
D0B_DQ12: U_DRAM0.U9 (DQ12_B), U_SOC.N5 (DDR_CH0_DQ12_B)
D0B_DQ13: U_DRAM0.V9 (DQ13_B), U_SOC.N2 (DDR_CH0_DQ13_B)
D0B_DQ14: U_DRAM0.Y9 (DQ14_B), U_SOC.J5 (DDR_CH0_DQ14_B)
D0B_DQ15: U_DRAM0.AA9 (DQ15_B), U_SOC.N6 (DDR_CH0_DQ15_B)
D0B_DQS0_c: U_DRAM0.V3 (DQS0_c_B), U_SOC.B1 (DDR_CH0_DQS0N_B)
D0B_DQS0_t: U_DRAM0.W3 (DQS0_t_B), U_SOC.B2 (DDR_CH0_DQS0P_B)
D0B_DQS1_c: U_DRAM0.V10 (DQS1_c_B), U_SOC.K2 (DDR_CH0_DQS1N_B)
D0B_DQS1_t: U_DRAM0.W10 (DQS1_t_B), U_SOC.K1 (DDR_CH0_DQS1P_B)
D1C_CA0: U_DRAM1.H2 (CA0_A), U_SOC.B18 (DDR_CH1_A0_C)
D1C_CA1: U_DRAM1.J2 (CA1_A), U_SOC.A21 (DDR_CH1_A1_C)
D1C_CA2: U_DRAM1.H9 (CA2_A), U_SOC.B22 (DDR_CH1_A2_C)
D1C_CA3: U_DRAM1.H10 (CA3_A), U_SOC.A7 (DDR_CH1_A3_C)
D1C_CA4: U_DRAM1.H11 (CA4_A), U_SOC.A10 (DDR_CH1_A4_C)
D1C_CA5: U_DRAM1.J11 (CA5_A), U_SOC.A15 (DDR_CH1_A5_C)
D1C_CKE0: R61.2, U_DRAM1.J4 (CKE0_A)
D1C_CKE0_SOC: R61.1, U_SOC.A18 (DDR_CH1_LP4/4X_CKE0/LP5_CS0_C)
D1C_CK_c: U_DRAM1.J9 (CK_c_A), U_SOC.D21 (DDR_CH1_CKB_C)
D1C_CK_t: U_DRAM1.J8 (CK_t_A), U_SOC.C21 (DDR_CH1_CK_C)
D1C_CS0: U_DRAM1.H4 (CS0_A), U_SOC.B15 (DDR_CH1_LP4/4X_CS0_C)
D1C_DMI0: U_DRAM1.C3 (DMI0_A), U_SOC.E17 (DDR_CH1_DM0_C)
D1C_DMI1: U_DRAM1.C10 (DMI1_A), U_SOC.D13 (DDR_CH1_DM1_C)
D1C_DQ0: U_DRAM1.B2 (DQ0_A), U_SOC.B20 (DDR_CH1_DQ0_C)
D1C_DQ1: U_DRAM1.C2 (DQ1_A), U_SOC.E20 (DDR_CH1_DQ1_C)
D1C_DQ2: U_DRAM1.E2 (DQ2_A), U_SOC.A20 (DDR_CH1_DQ2_C)
D1C_DQ3: U_DRAM1.F2 (DQ3_A), U_SOC.F20 (DDR_CH1_DQ3_C)
D1C_DQ4: U_DRAM1.F4 (DQ4_A), U_SOC.C17 (DDR_CH1_DQ4_C)
D1C_DQ5: U_DRAM1.E4 (DQ5_A), U_SOC.C16 (DDR_CH1_DQ5_C)
D1C_DQ6: U_DRAM1.C4 (DQ6_A), U_SOC.D17 (DDR_CH1_DQ6_C)
D1C_DQ7: U_DRAM1.B4 (DQ7_A), U_SOC.D16 (DDR_CH1_DQ7_C)
D1C_DQ8: U_DRAM1.B11 (DQ8_A), U_SOC.D10 (DDR_CH1_DQ8_C)
D1C_DQ9: U_DRAM1.C11 (DQ9_A), U_SOC.B12 (DDR_CH1_DQ9_C)
D1C_DQ10: U_DRAM1.E11 (DQ10_A), U_SOC.A12 (DDR_CH1_DQ10_C)
D1C_DQ11: U_DRAM1.F11 (DQ11_A), U_SOC.C10 (DDR_CH1_DQ11_C)
D1C_DQ12: U_DRAM1.F9 (DQ12_A), U_SOC.C13 (DDR_CH1_DQ12_C)
D1C_DQ13: U_DRAM1.E9 (DQ13_A), U_SOC.E13 (DDR_CH1_DQ13_C)
D1C_DQ14: U_DRAM1.C9 (DQ14_A), U_SOC.A16 (DDR_CH1_DQ14_C)
D1C_DQ15: U_DRAM1.B9 (DQ15_A), U_SOC.B16 (DDR_CH1_DQ15_C)
D1C_DQS0_c: U_DRAM1.E3 (DQS0_c_A), U_SOC.B9 (DDR_CH1_DQS0N_C)
D1C_DQS0_t: U_DRAM1.D3 (DQS0_t_A), U_SOC.A9 (DDR_CH1_DQS0P_C)
D1C_DQS1_c: U_DRAM1.E10 (DQS1_c_A), U_SOC.A4 (DDR_CH1_DQS1N_C)
D1C_DQS1_t: U_DRAM1.D10 (DQS1_t_A), U_SOC.A3 (DDR_CH1_DQS1P_C)
D1D_CA0: U_DRAM1.R2 (CA0_B), U_SOC.A26 (DDR_CH1_A0_D)
D1D_CA1: U_DRAM1.P2 (CA1_B), U_SOC.A27 (DDR_CH1_A1_D)
D1D_CA2: U_DRAM1.R9 (CA2_B), U_SOC.A30 (DDR_CH1_A2_D)
D1D_CA3: U_DRAM1.R10 (CA3_B), U_SOC.A36 (DDR_CH1_A3_D)
D1D_CA4: U_DRAM1.R11 (CA4_B), U_SOC.B33 (DDR_CH1_A4_D)
D1D_CA5: U_DRAM1.P11 (CA5_B), U_SOC.A38 (DDR_CH1_A5_D)
D1D_CKE0: R62.2, U_DRAM1.P4 (CKE0_B)
D1D_CKE0_SOC: R62.1, U_SOC.A35 (DDR_CH1_LP4/4X_CKE0/LP5_CS0_D)
D1D_CK_c: U_DRAM1.P9 (CK_c_B), U_SOC.D23 (DDR_CH1_CKB_D)
D1D_CK_t: U_DRAM1.P8 (CK_t_B), U_SOC.C23 (DDR_CH1_CK_D)
D1D_CS0: U_DRAM1.R4 (CS0_B), U_SOC.B30 (DDR_CH1_LP4/4X_CS0_D)
D1D_DMI0: U_DRAM1.Y3 (DMI0_B), U_SOC.D27 (DDR_CH1_DM0_D)
D1D_DMI1: U_DRAM1.Y10 (DMI1_B), U_SOC.C33 (DDR_CH1_DM1_D)
D1D_DQ0: U_DRAM1.AA2 (DQ0_B), U_SOC.A24 (DDR_CH1_DQ0_D)
D1D_DQ1: U_DRAM1.Y2 (DQ1_B), U_SOC.C25 (DDR_CH1_DQ1_D)
D1D_DQ2: U_DRAM1.V2 (DQ2_B), U_SOC.B24 (DDR_CH1_DQ2_D)
D1D_DQ3: U_DRAM1.U2 (DQ3_B), U_SOC.A28 (DDR_CH1_DQ3_D)
D1D_DQ4: U_DRAM1.U4 (DQ4_B), U_SOC.D25 (DDR_CH1_DQ4_D)
D1D_DQ5: U_DRAM1.V4 (DQ5_B), U_SOC.B28 (DDR_CH1_DQ5_D)
D1D_DQ6: U_DRAM1.Y4 (DQ6_B), U_SOC.C27 (DDR_CH1_DQ6_D)
D1D_DQ7: U_DRAM1.AA4 (DQ7_B), U_SOC.C29 (DDR_CH1_DQ7_D)
D1D_DQ8: U_DRAM1.AA11 (DQ8_B), U_SOC.D34 (DDR_CH1_DQ8_D)
D1D_DQ9: U_DRAM1.Y11 (DQ9_B), U_SOC.D29 (DDR_CH1_DQ9_D)
D1D_DQ10: U_DRAM1.V11 (DQ10_B), U_SOC.E29 (DDR_CH1_DQ10_D)
D1D_DQ11: U_DRAM1.U11 (DQ11_B), U_SOC.E32 (DDR_CH1_DQ11_D)
D1D_DQ12: U_DRAM1.U9 (DQ12_B), U_SOC.B32 (DDR_CH1_DQ12_D)
D1D_DQ13: U_DRAM1.V9 (DQ13_B), U_SOC.C34 (DDR_CH1_DQ13_D)
D1D_DQ14: U_DRAM1.Y9 (DQ14_B), U_SOC.C32 (DDR_CH1_DQ14_D)
D1D_DQ15: U_DRAM1.AA9 (DQ15_B), U_SOC.A32 (DDR_CH1_DQ15_D)
D1D_DQS0_c: U_DRAM1.V3 (DQS0_c_B), U_SOC.A41 (DDR_CH1_DQS0N_D)
D1D_DQS0_t: U_DRAM1.W3 (DQS0_t_B), U_SOC.B41 (DDR_CH1_DQS0P_D)
D1D_DQS1_c: U_DRAM1.V10 (DQS1_c_B), U_SOC.C36 (DDR_CH1_DQS1N_D)
D1D_DQS1_t: U_DRAM1.W10 (DQS1_t_B), U_SOC.D36 (DDR_CH1_DQS1P_D)
DDR_RESET: C319.1, U_DRAM0.T11 (RESET_n), U_DRAM1.T11 (RESET_n), U_SOC.AG1 (DDR_CH0_RESET_A)
DRAM0_ODT_A: R59.2, U_DRAM0.G2 (ODT_CA_A)
DRAM0_ODT_B: R60.2, U_DRAM0.T2 (ODT_CA_B)
DRAM0_ZQ: R58.1, U_DRAM0.A5 (ZQ0)
DRAM1_ODT_A: R64.2, U_DRAM1.G2 (ODT_CA_A)
DRAM1_ODT_B: R65.2, U_DRAM1.T2 (ODT_CA_B)
DRAM1_ZQ: R63.1, U_DRAM1.A5 (ZQ0)
EMMC_CLK: R70.2, U_EMMC.M6 (CLK)
EMMC_CLK_SOC: R70.1, U_SOC.AB41 (EMMC_CLKOUT/GPIO2_A1_d)
EMMC_CMD: R71.2, U_EMMC.M5 (CMD), U_SOC.AE42 (EMMC_CMD/FSPI_CLK_M0/GPIO2_A0_u)
EMMC_DAT0: U_EMMC.A3 (DAT0), U_SOC.Y41 (EMMC_D0/FSPI_D0_M0/GPIO2_D0_u)
EMMC_DAT1: U_EMMC.A4 (DAT1), U_SOC.Y40 (EMMC_D1/FSPI_D1_M0/GPIO2_D1_u)
EMMC_DAT2: U_EMMC.A5 (DAT2), U_SOC.AA41 (EMMC_D2/FSPI_D2_M0/GPIO2_D2_u)
EMMC_DAT3: U_EMMC.B2 (DAT3), U_SOC.AA42 (EMMC_D3/FSPI_D3_M0/GPIO2_D3_u)
EMMC_DAT4: U_EMMC.B3 (DAT4), U_SOC.AB42 (EMMC_D4/I2C1_SCL_M3/UART5_RX_M2/GPIO2_D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)
EMMC_DAT5: U_EMMC.B4 (DAT5), U_SOC.AD42 (EMMC_D5/I2C1_SDA_M3/UART5_TX_M2/GPIO2_D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)
EMMC_DAT6: U_EMMC.B5 (DAT6), U_SOC.AD41 (EMMC_D6/FSPI_CS0N_M0/GPIO2_D6_u)
EMMC_DAT7: U_EMMC.B6 (DAT7), U_SOC.AE41 (EMMC_D7/FSPI_CS1N_M0/GPIO2_D7_u)
EMMC_DS: U_EMMC.H5 (DS), U_SOC.AC40 (EMMC_DATA_STROBE/I2C2_SDA_M2/UART5_CTSN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)
EMMC_RST_n: U_EMMC.K5 (RST_n), U_SOC.AD40 (EMMC_RSTN/I2C2_SCL_M2/UART5_RTSN_M1/GPI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)
EMMC_VDDI: C320.1, PF25.1, U_EMMC.C2 (VDDi)
ESTOP_OK: J2.1, J10.4, J11.4, J12.4, J13.4, J14.4, R1.1, R85.1
ESTOP_OK_RT: R85.2, U_RT.15 (PC0)
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C7.2, C8.2, C9.2, C10.2, C11.2, C12.2, C13.2, C14.2, C15.2, C16.2, C17.2, C18.2, C20.2, C21.2, C22.2, C23.2, C24.2, C25.2, C26.2, C27.2, C28.2, C29.2, C30.2, C31.2, C32.2, C33.2, C34.2, C35.2, C36.2, C37.2, C38.2, C39.2, C40.2, C41.2, C42.2, C43.2, C44.2, C45.2, C46.2, C47.2, C48.2, C49.2, C50.2, C51.2, C52.2, C53.2, C54.2, C55.2, C56.2, C57.2, C58.2, C59.2, C60.2, C61.2, C62.2, C63.2, C64.2, C65.2, C68.2, C69.2, C70.2, C71.2, C72.2, C73.2, C74.2, C75.2, C76.2, C77.2, C78.2, C79.2, C80.2, C81.2, C82.2, C84.2, C85.2, C86.2, C87.2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
HDMI_eDP_TX0_REXT: R51.1, U_SOC.AY3 (HDMI/eDP_TX0_REXT)
HSE_IN: C341.1, U_RT.12 (PH0), Y2.1
HSE_OUT: C342.1, U_RT.13 (PH1), Y2.3
I2C0_SCL: R34.2, U4.A3 (SCL), U5.A3 (SCL), U_SOC.AH41 (I2S1_SDO0_M1/CPU_BIG0_AVS/I2C0_SCL_M2/U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)
I2C0_SDA: R35.2, U4.B1 (SDA), U5.B1 (SDA), U_SOC.AG41 (I2S1_SDO1_M1/I2C0_SDA_M2/UART1_RX_M2/SP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)
I2C2_SCL: R36.2, U6.A3 (SCL), U_SOC.AK39 (I2S1_LRCK_TX_M1/PWM0_M0/I2C2_SCL_M0/SPI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)
I2C2_SDA: R37.2, U6.B1 (SDA), U_SOC.AM40 (I2S1_SCLK_RX_M1/PDM0_CLK0_M1/PWM1_M0/I2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)
LED_B: R83.1, U_RT.2 (PE3)
LED_B_A: D6.2 (A), R83.2
LED_G: R82.1, U_RT.98 (PE1)
LED_G_A: D5.2 (A), R82.2
LED_R: R81.1, U_RT.97 (PE0)
LED_R_A: D4.2 (A), R81.2
MIPI_DC_PHY0_VREG: C275.1, U_SOC.AT33 (MIPI_D/C_PHY0_VREG)
MIPI_DC_PHY1_VREG: C276.1, U_SOC.AT27 (MIPI_D/C_PHY1_VREG)
NLDO_EN: C111.1, R38.2, U7.1 (EN)
NLDO_FB: C113.2, R39.2, R40.1, U7.5 (FB)
NLDO_LX: L16.1, U7.3 (LX)
NPU_LX: L15.1, U6.D3 (LX), U6.D4 (LX), U6.E3 (LX), U6.E4 (LX)
PACK_OK: J2.2, R2.1, R86.1
PACK_OK_RT: R86.2, U_RT.16 (PC1)
PFAIL_DIV: C5.1, R3.2, R4.1, U_RT.22 (PA0)
PMIC_EXT_EN: R38.1, U_PMIC.39 (EXT_EN)
PMIC_FB6: C66.2, R14.2, R15.1, U_PMIC.31 (FB6)
PMIC_FB9: C67.2, R16.2, R17.1, U_PMIC.66 (FB9)
PMIC_INT_L: R24.2, U_PMIC.19 (INT), U_SOC.W42 (PMIC_INT_L/GPIO0_A7_u)
PMIC_NLDO5: C77.1, U_PMIC.8 (NLDO5)
PMIC_PWRCTRL2: R23.1, U_PMIC.61 (PWRCTRL2)
PMIC_PWRCTRL3: R22.1, U_PMIC.16 (MISO/PWRCTRL3)
PMIC_RESET_L: C86.1, C272.1, R25.2, R46.2, U_PMIC.40 (RESETB), U_SOC.V42 (NPOR)
PMIC_SLEEP1: U_PMIC.62 (PWRCTRL1), U_SOC.W41 (PMIC_SLEEP1/GPIO0_A2_d)
PMIC_SPI_CLK: R47.2, U_PMIC.17 (CLK/SCL)
PMIC_SPI_CLK_SOC: R47.1, U_SOC.Y39 (SPI2_CLK_M2/SDMMC_PWREN/PMU_DEBUG/GPIO0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)
PMIC_SPI_CS: R21.1, U_PMIC.18 (CS), U_SOC.W40 (SPI2_CS0_M2/I2C1_SDA_M1/PWM5_M0/UART0_T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)
PMIC_SPI_MOSI: R48.2, U_PMIC.15 (MOSI/SDA)
PMIC_SPI_MOSI_SOC: R48.1, U_SOC.W39 (SPI2_MOSI_M2/I2C0_SDA_M0/GPIO0_A6_z)
PMIC_SW1: L3.1, U_PMIC.50 (SW1), U_PMIC.51 (SW1)
PMIC_SW2: L4.1, U_PMIC.35 (SW2), U_PMIC.36 (SW2)
PMIC_SW3: L5.1, U_PMIC.55 (SW3)
PMIC_SW4: L6.1, U_PMIC.23 (SW4)
PMIC_SW5: L7.1, U_PMIC.45 (SW5)
PMIC_SW6: L8.1, U_PMIC.29 (SW6)
PMIC_SW7: L9.1, U_PMIC.42 (SW7)
PMIC_SW8: L10.1, U_PMIC.6 (SW8)
PMIC_SW9: L11.1, U_PMIC.68 (SW9)
PMIC_SW10: L12.1, U_PMIC.26 (SW10)
PMIC_VCCIO: C82.1, PF20.1, U_PMIC.20 (VCCIO)
PMIC_VDC: C84.1, R19.2, R20.1, U_PMIC.32 (VDC)
PMIC_VDC_K: C83.2, D3.1 (K), R19.1
PWRON_L: C85.1, SW1.1, U_PMIC.4 (PWRON)
RECOVERY_KEY: C274.1, R50.2, SW2.1, U_SOC.AY13 (SARADC_IN1)
RT_BOOT0: R80.1, U_RT.94 (BOOT0), U_SOC.U37 (I2S0_SDO1/I2C7_SCL_M0/UART6_TX_M2/SPI1_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)
RT_CS_n: U_RT.51 (PB12), U_SOC.M39 (PDM1_CLK0_M1/UART7_RX_M2/SPI0_CS0_M2/GP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)
RT_IRQ: U_RT.37 (PE7), U_SOC.G37 (SPI2_MISO_M0/GPIO1_A4_d)
RT_MISO: U_RT.53 (PB14), U_SOC.G39 (PDM1_SDI2_M1/SPI0_MISO_M2/GPIO1_B1_d)
RT_MOSI: U_RT.54 (PB15), U_SOC.M38 (PDM1_SDI3_M1/UART4_RX_M2/SPI0_MOSI_M2/G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)
RT_NRST: C340.1, J8.3 (~RESET), U_RT.14 (NRST), U_SOC.H38 (PDM1_SDI0_M1/PCIE20X1_1_PERSTN_M2/PWM3_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)
RT_RX: U_RT.69 (PA10), U_SOC.L40 (PCIE20X1_1_WAKEN_M2/I2C2_SCL_M4/UART6_T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)
RT_SCK: U_RT.52 (PB13), U_SOC.M37 (PDM1_CLK1_M1/SATA0_ACT_LED_M1/UART4_TX_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)
RT_TX: U_RT.68 (PA9), U_SOC.G40 (PCIE20X1_1_CLKREQN_M2/DP0_HPDIN_M2/I2C2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)
S0_3V3_EN: R41.2, R42.1, U8.4 (EN)
SARADC_IN0_BOOT: C273.1, R49.2, U_SOC.AW15 (SARADC_IN0_BOOT)
SGM_OCB: R43.1, U8.3 (OCB)
SOC_PWR_EN: R9.2, R84.2, U3.3 (EN)
SOC_PWR_EN_RT: R84.1, U_RT.61 (PD14)
SOC_UART2_RX: J7.2, U_SOC.AH40 (I2S1_SCLK_TX_M1/JTAG_TMS_M2/I2C1_SDA_M0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)
SOC_UART2_TX: J7.1, U_SOC.AH39 (I2S1_MCLK_M1/JTAG_TCK_M2/I2C1_SCL_M0/UA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)
SOC_ZQ_0A: R66.1, U_SOC.AM1 (DDR_CH0_ZQ_A)
SOC_ZQ_0B: R67.1, U_SOC.C1 (DDR_CH0_ZQ_B)
SOC_ZQ_1C: R68.1, U_SOC.A5 (DDR_CH1_ZQ_C)
SOC_ZQ_1D: R69.1, U_SOC.A40 (DDR_CH1_ZQ_D)
SWCLK: J8.4 (SWCLK), U_RT.76 (PA14(JTCK)
SWDIO: J8.2 (SWDIO), U_RT.72 (PA13(JTMS)
SWO: J8.6 (SWO), U_RT.89 (PB3(JTDO)
SYNC0: J10.3, R116.2
SYNC1: J11.3, R117.2
SYNC2: J12.3, R118.2
SYNC3: J13.3, R119.2
SYNC4: J14.3, R120.2
SYNC_OUT: R116.1, R117.1, R118.1, R119.1, R120.1, U_RT.39 (PE9)
TSADC_SHUT: R46.1, U_SOC.AC39 (TSADC_SHUT_ORG/TSADC_SHUT/GPIO0_A1_z)
TYPEC0_DP0_REXT: R52.1, U_SOC.AW11 (TYPEC0_DP0_REXT)
TYPEC0_USB20_OTG0_REXT: R53.1, U_SOC.AU7 (TYPEC0_USB20_OTG0_REXT)
U1_BOOT: C6.1, U1.7 (BOOT)
U1_FB: R5.2, R6.1, U1.5 (FB)
U1_SW: C6.2, L1.1, U1.8 (SW)
U1_VCC: C7.1, U1.6 (VCC)
U3_BOOT: C19.1, U3.7 (BOOT)
U3_FB: R7.2, R8.1, U3.5 (FB)
U3_SW: C19.2, L2.1, U3.8 (SW)
U3_VCC: C20.1, U3.6 (VCC)
USB20_HOST0_REXT: R54.1, U_SOC.AW5 (USB20_HOST0_REXT)
USB20_HOST1_REXT: R55.1, U_SOC.AU6 (USB20_HOST1_REXT)
USB_CC1: J3.A5 (CC1), R72.1
USB_CC2: J3.B5 (CC2), R73.1
USB_C_DM: J3.A7 (D-), J3.B7 (D-), U9.3 (I/O2)
USB_C_DP: J3.A6 (D+), J3.B6 (D+), U9.1 (I/O1)
USB_OTG_DM: U9.4 (I/O2), U_SOC.AY10 (TYPEC0_USB20_OTG_DM)
USB_OTG_DP: U9.6 (I/O1), U_SOC.AY11 (TYPEC0_USB20_OTG_DP)
USB_VBUS: J3.A4 (VBUS), J3.A9 (VBUS), J3.B4 (VBUS), J3.B9 (VBUS), R74.1, U9.5 (VBUS)
USB_VBUSDET: R74.2, R75.1, U_SOC.AV10 (TYPEC0_USB20_VBUSDET)
VCAP1: C338.1, U_RT.48 (VCAP)
VCAP2: C339.1, U_RT.73 (VCAP)
VCC1V8_PMU_DDR_S3: C219.1, C220.1, C277.1, C278.1, C279.1, C298.1, C299.1, C300.1, PF21.1, R26.2, U_DRAM0.F1 (VDD1), U_DRAM0.F12 (VDD1), U_DRAM0.G4 (VDD1), U_DRAM0.G9 (VDD1), U_DRAM0.T4 (VDD1), U_DRAM0.T9 (VDD1), U_DRAM0.U1 (VDD1), U_DRAM0.U12 (VDD1), U_DRAM1.F1 (VDD1), U_DRAM1.F12 (VDD1), U_DRAM1.G4 (VDD1), U_DRAM1.G9 (VDD1), U_DRAM1.T4 (VDD1), U_DRAM1.T9 (VDD1), U_DRAM1.U1 (VDD1), U_DRAM1.U12 (VDD1), U_SOC.N37 (PMUIO1_1V8), U_SOC.R36 (PMUIO1_1V8), U_SOC.V37 (PMUIO2_1V8), U_SOC.Y37 (PMUIO2_1V8)
VCCA_1V8_S0: C69.1, C224.1, C225.1, C226.1, C227.1, C228.1, C229.1, C230.1, C231.1, C232.1, C233.1, C234.1, C235.1, C236.1, R28.1, R49.1, R50.1, U_PMIC.58 (PLDO2), U_SOC.AB25 (PLL_AVDD1V8), U_SOC.AK12 (HDMI/eDP_TX0_VDD_IO_1V8), U_SOC.AL14 (HDMI/eDP_TX0_VDD_CMN_1V8), U_SOC.AM35 (MIPI_CSI0_AVCC1V8), U_SOC.AP23 (SARADC_AVDD_1V8), U_SOC.AR23 (TYPEC0_DP0_VDDH_1V8), U_SOC.G34 (PCIE20_SATA30_0_AVDD_1V8), U_SOC.H34 (PCIE20_SATA30_USB30_2_AVDD_1V8), U_SOC.N35 (OSC_1V8_1), U_SOC.N36 (OSC_1V8_2)
VCCA_3V3_S0: C71.1, C269.1, U_PMIC.63 (PLDO4), U_SOC.AT10 (USB20_AVDD_3V3)
VCCIO_SD_S0: C72.1, C265.1, U_PMIC.65 (PLDO5), U_SOC.AK10 (VCCIO2)
VCC_1V1_NLDO_S3: C80.1, C81.1, C113.1, C114.1, C115.1, L16.2, PF19.1, R39.1, U_PMIC.9 (VCC14), U_PMIC.13 (VCC13)
VCC_1V8_S0: C68.1, C256.1, C257.1, C258.1, C259.1, C260.1, C261.1, C262.1, C263.1, R41.1, U_PMIC.60 (PLDO1), U_SOC.AF36 (VCCIO5_1V8), U_SOC.AJ34 (VCCIO6_1V8), U_SOC.AK11 (VCCIO2_1V8), U_SOC.AT13 (USB20_AVDD_1V8_1), U_SOC.AT14 (USB20_AVDD_1V8_2), U_SOC.G27 (VCCIO4_1V8), U_SOC.G28 (VCCIO4_1V8), U_SOC.H31 (VCCIO1_1V8)
VCC_1V8_S3: C64.1, C65.1, C264.1, C323.1, C324.1, L12.2, PF18.1, R24.1, R25.1, R26.1, R71.1, U_EMMC.C6 (VCCQ), U_EMMC.M4 (VCCQ), U_EMMC.N4 (VCCQ), U_EMMC.P3 (VCCQ), U_EMMC.P5 (VCCQ), U_PMIC.25 (VOUT10), U_SOC.AB35 (EMMCIO_1V8_1), U_SOC.AC35 (EMMCIO_1V8_2)
VCC_2V0_PLDO_S3: C55.1, C56.1, C78.1, L9.2, PF16.1, U_PMIC.41 (VOUT7), U_PMIC.59 (VCC11)
VCC_3V3_PMU: C221.1, PF22.1, R27.2, R34.1, R35.1, R36.1, R37.1, U_SOC.V35 (PMUIO2), U_SOC.V36 (PMUIO2)
VCC_3V3_S0: C117.1, C266.1, C267.1, C268.1, C325.1, C326.1, J5.22, J6.22, PF32.1, R76.1, R77.1, R78.1, R79.1, U8.1 (VOUT), U_SOC.AC33 (VCCIO5), U_SOC.AC34 (VCCIO5), U_SOC.AL33 (VCCIO6), U_SOC.AM33 (VCCIO6), U_SOC.G31 (VCCIO4)
VCC_3V3_S3: C58.1, C59.1, C116.1, C321.1, C322.1, L10.2, PF17.1, R27.1, R32.1, U8.5 (IN), U_EMMC.E6 (VCC), U_EMMC.F5 (VCC), U_EMMC.J10 (VCC), U_EMMC.K9 (VCC), U_PMIC.5 (VOUT8)
VCC_SYSIN: C24.1, C25.1, C26.1, C27.1, C28.1, C33.1, C38.1, C43.1, C48.1, C51.1, C54.1, C57.1, C60.1, C63.1, C79.1, C83.1, C87.1, C88.1, C95.1, C96.1, C103.1, C104.1, C112.1, L2.2, PF4.1, R7.1, U4.D1 (VIN), U4.D2 (VIN), U4.E1 (VIN), U4.E2 (VIN), U5.D1 (VIN), U5.D2 (VIN), U5.E1 (VIN), U5.E2 (VIN), U6.D1 (VIN), U6.D2 (VIN), U6.E1 (VIN), U6.E2 (VIN), U7.4 (VIN), U_PMIC.1 (VCC9), U_PMIC.7 (VCC8), U_PMIC.21 (VCCA), U_PMIC.22 (VCC4), U_PMIC.27 (VCC10), U_PMIC.28 (VCC6), U_PMIC.33 (VCC2), U_PMIC.34 (VCC2), U_PMIC.43 (VCC7), U_PMIC.44 (VCC5), U_PMIC.52 (VCC1), U_PMIC.53 (VCC1), U_PMIC.54 (VCC3), U_PMIC.64 (VCC12)
VDD2_DDR_S3: C52.1, C53.1, C66.1, C213.1, C214.1, C280.1, C281.1, C282.1, C283.1, C284.1, C285.1, C286.1, C287.1, C288.1, C289.1, C301.1, C302.1, C303.1, C304.1, C305.1, C306.1, C307.1, C308.1, C309.1, C310.1, L8.2, PF14.1, R14.1, R59.1, R60.1, R64.1, R65.1, U_DRAM0.A4 (VDD2), U_DRAM0.A9 (VDD2), U_DRAM0.AB4 (VDD2), U_DRAM0.AB9 (VDD2), U_DRAM0.F5 (VDD2), U_DRAM0.F8 (VDD2), U_DRAM0.H1 (VDD2), U_DRAM0.H5 (VDD2), U_DRAM0.H8 (VDD2), U_DRAM0.H12 (VDD2), U_DRAM0.K1 (VDD2), U_DRAM0.K3 (VDD2), U_DRAM0.K10 (VDD2), U_DRAM0.K12 (VDD2), U_DRAM0.N1 (VDD2), U_DRAM0.N3 (VDD2), U_DRAM0.N10 (VDD2), U_DRAM0.N12 (VDD2), U_DRAM0.R1 (VDD2), U_DRAM0.R5 (VDD2), U_DRAM0.R8 (VDD2), U_DRAM0.R12 (VDD2), U_DRAM0.U5 (VDD2), U_DRAM0.U8 (VDD2), U_DRAM1.A4 (VDD2), U_DRAM1.A9 (VDD2), U_DRAM1.AB4 (VDD2), U_DRAM1.AB9 (VDD2), U_DRAM1.F5 (VDD2), U_DRAM1.F8 (VDD2), U_DRAM1.H1 (VDD2), U_DRAM1.H5 (VDD2), U_DRAM1.H8 (VDD2), U_DRAM1.H12 (VDD2), U_DRAM1.K1 (VDD2), U_DRAM1.K3 (VDD2), U_DRAM1.K10 (VDD2), U_DRAM1.K12 (VDD2), U_DRAM1.N1 (VDD2), U_DRAM1.N3 (VDD2), U_DRAM1.N10 (VDD2), U_DRAM1.N12 (VDD2), U_DRAM1.R1 (VDD2), U_DRAM1.R5 (VDD2), U_DRAM1.R8 (VDD2), U_DRAM1.R12 (VDD2), U_DRAM1.U5 (VDD2), U_DRAM1.U8 (VDD2), U_PMIC.30 (VOUT6), U_SOC.G24 (DDR_CH1_VDDQ_CKE)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
VDDA_0V75_S0: C75.1, C237.1, C238.1, C239.1, C240.1, C241.1, C242.1, C243.1, C244.1, C245.1, C246.1, C247.1, C248.1, U_PMIC.11 (NLDO3), U_SOC.AM13 (HDMI/eDP_TX0_VDD_0V75_1), U_SOC.AM37 (MIPI_CSI0_AVCC0V75), U_SOC.AN8 (OTP_VDDOTP_0V75), U_SOC.AN10 (HDMI/eDP_TX0_AVDD_0V75), U_SOC.AN12 (HDMI/eDP_TX0_VDD_0V75_2), U_SOC.AR27 (MIPI_D/C_PHY1_VDD), U_SOC.AR33 (MIPI_D/C_PHY0_VDD), U_SOC.AT11 (USB20_DVDD_0V75_1), U_SOC.AT12 (USB20_DVDD_0V75_2), U_SOC.Y26 (PLL_DVDD0V75)
VDDA_0V85_S0: C76.1, C249.1, C250.1, C251.1, C252.1, C253.1, U_PMIC.10 (NLDO4), U_SOC.AP18 (TYPEC0_DP0_VDDA_0V85_1), U_SOC.AR19 (TYPEC0_DP0_VDDA_0V85_2), U_SOC.AT18 (TYPEC0_DP0_VDD_0V85), U_SOC.H36 (PCIE20_SATA30_0_AVDD_0V85), U_SOC.J36 (PCIE20_SATA30_USB30_2_AVDD_0V85)
VDDA_1V2_S0: C70.1, C254.1, C255.1, U_PMIC.57 (PLDO3)
VDDA_DDR_PLL_S0: C74.1, C215.1, C216.1, U_PMIC.12 (NLDO2), U_SOC.AB14 (DDR_CH0_PLL_DVDD), U_SOC.M16 (DDR_CH1_PLL_DVDD)
VDDA_RT: C336.1, C337.1, FB7.2, PF24.1, U_RT.21 (VDDA)
VDDQ_DDR_S0: C61.1, C62.1, C67.1, C203.1, C204.1, C205.1, C206.1, C207.1, C208.1, C209.1, C210.1, C211.1, C212.1, C290.1, C291.1, C292.1, C293.1, C294.1, C295.1, C296.1, C297.1, C311.1, C312.1, C313.1, C314.1, C315.1, C316.1, C317.1, C318.1, L11.2, PF15.1, R16.1, R58.2, R63.2, R66.2, R67.2, R68.2, R69.2, U_DRAM0.AA3 (VDDQ), U_DRAM0.AA5 (VDDQ), U_DRAM0.AA8 (VDDQ), U_DRAM0.AA10 (VDDQ), U_DRAM0.B3 (VDDQ), U_DRAM0.B5 (VDDQ), U_DRAM0.B8 (VDDQ), U_DRAM0.B10 (VDDQ), U_DRAM0.D1 (VDDQ), U_DRAM0.D5 (VDDQ), U_DRAM0.D8 (VDDQ), U_DRAM0.D12 (VDDQ), U_DRAM0.F3 (VDDQ), U_DRAM0.F10 (VDDQ), U_DRAM0.U3 (VDDQ), U_DRAM0.U10 (VDDQ), U_DRAM0.W1 (VDDQ), U_DRAM0.W5 (VDDQ), U_DRAM0.W8 (VDDQ), U_DRAM0.W12 (VDDQ), U_DRAM1.AA3 (VDDQ), U_DRAM1.AA5 (VDDQ), U_DRAM1.AA8 (VDDQ), U_DRAM1.AA10 (VDDQ), U_DRAM1.B3 (VDDQ), U_DRAM1.B5 (VDDQ), U_DRAM1.B8 (VDDQ), U_DRAM1.B10 (VDDQ), U_DRAM1.D1 (VDDQ), U_DRAM1.D5 (VDDQ), U_DRAM1.D8 (VDDQ), U_DRAM1.D12 (VDDQ), U_DRAM1.F3 (VDDQ), U_DRAM1.F10 (VDDQ), U_DRAM1.U3 (VDDQ), U_DRAM1.U10 (VDDQ), U_DRAM1.W1 (VDDQ), U_DRAM1.W5 (VDDQ), U_DRAM1.W8 (VDDQ), U_DRAM1.W12 (VDDQ), U_PMIC.67 (VOUT9), U_SOC.H14 (DDR_CH1_VDDQ_1), U_SOC.H15 (DDR_CH1_VDDQ_2), U_SOC.H16 (DDR_CH1_VDDQ_3)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
VDD_0V75_S3: C73.1, C222.1, C223.1, U_PMIC.14 (NLDO1), U_SOC.AJ36 (PMU_0V75_1), U_SOC.AJ37 (PMU_0V75_2)
VDD_CPU_BIG0_MEM_S0: C118.1, FB1.2, PF26.1, U_SOC.K27 (VDD_CPU_BIG0_MEM), U_SOC.K28 (VDD_CPU_BIG0_MEM), U_SOC.K29 (VDD_CPU_BIG0_MEM), U_SOC.K30 (VDD_CPU_BIG0_MEM)
VDD_CPU_BIG0_S0: C89.1, C90.1, C91.1, C92.1, C93.1, C94.1, C124.1, C125.1, C126.1, C127.1, C128.1, C129.1, C130.1, C131.1, C132.1, C133.1, FB1.1, L13.2, PF6.1, R29.1, U4.A4 (VOUT), U_SOC.M24 (VDD_CPU_BIG0), U_SOC.M25 (VDD_CPU_BIG0), U_SOC.M28 (VDD_CPU_BIG0), U_SOC.M29 (VDD_CPU_BIG0), U_SOC.M30 (VDD_CPU_BIG0), U_SOC.N24 (VDD_CPU_BIG0), U_SOC.N25 (VDD_CPU_BIG0), U_SOC.P23 (VDD_CPU_BIG0), U_SOC.R23 (VDD_CPU_BIG0), U_SOC.R24 (VDD_CPU_BIG0)
VDD_CPU_BIG1_MEM_S0: C119.1, FB2.2, PF27.1, U_SOC.V26 (VDD_CPU_BIG1_MEM), U_SOC.V27 (VDD_CPU_BIG1_MEM), U_SOC.V28 (VDD_CPU_BIG1_MEM), U_SOC.V29 (VDD_CPU_BIG1_MEM)
VDD_CPU_BIG1_S0: C97.1, C98.1, C99.1, C100.1, C101.1, C102.1, C134.1, C135.1, C136.1, C137.1, C138.1, C139.1, C140.1, C141.1, C142.1, C143.1, FB2.1, L14.2, PF7.1, R30.1, U5.A4 (VOUT), U_SOC.R26 (VDD_CPU_BIG1), U_SOC.R27 (VDD_CPU_BIG1), U_SOC.R28 (VDD_CPU_BIG1), U_SOC.R29 (VDD_CPU_BIG1), U_SOC.R30 (VDD_CPU_BIG1), U_SOC.R31 (VDD_CPU_BIG1), U_SOC.R32 (VDD_CPU_BIG1), U_SOC.R33 (VDD_CPU_BIG1), U_SOC.T26 (VDD_CPU_BIG1), U_SOC.U26 (VDD_CPU_BIG1)
VDD_CPU_LIT_MEM_S0: C120.1, FB3.2, PF28.1, U_SOC.AA28 (VDD_CPU_LIT_MEM), U_SOC.AA29 (VDD_CPU_LIT_MEM), U_SOC.AA30 (VDD_CPU_LIT_MEM)
VDD_CPU_LIT_S0: C34.1, C35.1, C36.1, C37.1, C144.1, C145.1, C146.1, C147.1, C148.1, C149.1, C150.1, C151.1, C152.1, FB3.1, L4.2, PF10.1, R11.1, U_PMIC.37 (VOUT2), U_SOC.AB31 (VDD_CPU_LIT), U_SOC.AC27 (VDD_CPU_LIT), U_SOC.AC28 (VDD_CPU_LIT), U_SOC.AC29 (VDD_CPU_LIT), U_SOC.AC30 (VDD_CPU_LIT), U_SOC.AC31 (VDD_CPU_LIT), U_SOC.AD26 (VDD_CPU_LIT), U_SOC.AD27 (VDD_CPU_LIT), U_SOC.AE27 (VDD_CPU_LIT)
VDD_DDR_S0: C49.1, C50.1, C195.1, C196.1, C197.1, C198.1, C199.1, C200.1, C201.1, C202.1, L7.2, PF13.1, R18.1, U_PMIC.46 (VOUT5), U_SOC.J18 (DDR_CH1_VDD_1), U_SOC.J20 (DDR_CH1_VDD_MIF_1), U_SOC.K18 (DDR_CH1_VDD_2), U_SOC.K20 (DDR_CH1_VDD_MIF_2), U_SOC.L18 (DDR_CH1_VDD_3), U_SOC.L20 (DDR_CH1_VDD_MIF_3), U_SOC.T12 (DDR_CH0_VDD_1), U_SOC.T13 (DDR_CH0_VDD_2), U_SOC.U12 (DDR_CH0_VDD_3), U_SOC.U13 (DDR_CH0_VDD_4), U_SOC.V12 (DDR_CH0_VDD_MIF_1), U_SOC.V13 (DDR_CH0_VDD_MIF_2), U_SOC.V14 (DDR_CH0_VDD_MIF_3)
VDD_GPU_MEM_S0: C121.1, FB4.2, PF29.1, U_SOC.AJ18 (VDD_GPU_MEM), U_SOC.AK18 (VDD_GPU_MEM), U_SOC.AL18 (VDD_GPU_MEM)
VDD_GPU_S0: C29.1, C30.1, C31.1, C32.1, C153.1, C154.1, C155.1, C156.1, C157.1, C158.1, C159.1, C160.1, C161.1, C162.1, C163.1, C164.1, FB4.1, L3.2, PF9.1, R10.1, U_PMIC.49 (VOUT1), U_SOC.AH18 (VDD_GPU), U_SOC.AH19 (VDD_GPU), U_SOC.AH20 (VDD_GPU), U_SOC.AH21 (VDD_GPU), U_SOC.AJ19 (VDD_GPU), U_SOC.AJ20 (VDD_GPU), U_SOC.AJ21 (VDD_GPU), U_SOC.AK21 (VDD_GPU), U_SOC.AL21 (VDD_GPU), U_SOC.AM21 (VDD_GPU), U_SOC.AM22 (VDD_GPU), U_SOC.AN21 (VDD_GPU), U_SOC.AN22 (VDD_GPU)
VDD_LOGIC_S0: C39.1, C40.1, C41.1, C42.1, C174.1, C175.1, C176.1, C177.1, C178.1, C179.1, C180.1, C181.1, C182.1, C183.1, C184.1, C185.1, C186.1, C187.1, L5.2, PF11.1, R12.1, U_PMIC.56 (VOUT3), U_SOC.AF12 (VDD_LOGIC), U_SOC.AF13 (VDD_LOGIC), U_SOC.AH11 (VDD_LOGIC), U_SOC.AH12 (VDD_LOGIC), U_SOC.AH13 (VDD_LOGIC), U_SOC.AH14 (VDD_LOGIC), U_SOC.AH15 (VDD_LOGIC), U_SOC.AH23 (VDD_LOGIC), U_SOC.AH24 (VDD_LOGIC), U_SOC.AJ15 (VDD_LOGIC), U_SOC.AJ31 (VDD_LOGIC), U_SOC.AJ32 (VDD_LOGIC), U_SOC.AK15 (VDD_LOGIC), U_SOC.AL31 (VDD_LOGIC), U_SOC.H27 (VDD_LOGIC), U_SOC.J27 (VDD_LOGIC), U_SOC.W33 (VDD_LOGIC), U_SOC.Y33 (VDD_LOGIC)
VDD_NPU_MEM_S0: C122.1, FB5.2, PF30.1, U_SOC.AH25 (VDD_NPU_MEM), U_SOC.AH26 (VDD_NPU_MEM), U_SOC.AJ25 (VDD_NPU_MEM), U_SOC.AK25 (VDD_NPU_MEM)
VDD_NPU_S0: C105.1, C106.1, C107.1, C108.1, C109.1, C110.1, C165.1, C166.1, C167.1, C168.1, C169.1, C170.1, C171.1, C172.1, C173.1, FB5.1, L15.2, PF8.1, R31.1, U6.A4 (VOUT), U_SOC.AK27 (VDD_NPU), U_SOC.AK28 (VDD_NPU), U_SOC.AK29 (VDD_NPU), U_SOC.AL28 (VDD_NPU), U_SOC.AL29 (VDD_NPU), U_SOC.AL30 (VDD_NPU), U_SOC.AM30 (VDD_NPU), U_SOC.AN30 (VDD_NPU), U_SOC.AP30 (VDD_NPU)
VDD_VDENC_MEM_S0: C123.1, FB6.2, PF31.1, U_SOC.W17 (VDD_VDENC_MEM), U_SOC.Y17 (VDD_VDENC_MEM)
VDD_VDENC_S0: C44.1, C45.1, C46.1, C47.1, C188.1, C189.1, C190.1, C191.1, C192.1, C193.1, C194.1, FB6.1, L6.2, PF12.1, R13.1, U_PMIC.24 (VOUT4), U_SOC.AC16 (VDD_VDENC), U_SOC.AD15 (VDD_VDENC), U_SOC.P15 (VDD_VDENC), U_SOC.R15 (VDD_VDENC), U_SOC.T15 (VDD_VDENC), U_SOC.U15 (VDD_VDENC), U_SOC.W16 (VDD_VDENC)
VSEL2: U4.A1 (VSEL), U_SOC.AD39 (PMIC_SLEEP2/GPIO0_A3_d)
VSEL3: U6.A1 (VSEL), U_SOC.AM38 (PMIC_SLEEP3/GPIO0_C1_d)
VSEL4: R22.2, U_SOC.AG36 (PMIC_SLEEP4/GPIO0_C2_d)
VSEL5: R23.2, U_SOC.AH38 (PMIC_SLEEP5/GPIO0_C3_d)
VSEL6: U5.A1 (VSEL), U_SOC.AG42 (PMIC_SLEEP6/PDM0_SDI3_M1/GPIO0_D6_d)
XIN_24M: C271.1, R45.2, U_SOC.T41 (XIN_24M), Y1.3
XOUT_24M: R44.1, R45.1, U_SOC.T42 (XOUT_24M)
XOUT_X1: C270.1, R44.2, Y1.1

Board: 8 copper layers, 571 parts (92 on the bottom side), 400 nets, no tracks yet.
